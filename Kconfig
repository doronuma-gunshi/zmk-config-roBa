## Kconfig
```kconfig
config ZMK_BEHAVIOR_BATTERY_PRINT
    bool
    default y
    depends on DT_HAS_ZMK_BEHAVIOR_BATTERY_PRINT_ENABLED
```
